# Keil uVision project wiznet_w5500_tcp.uvproj, settings and files
target wiznet_w5500_tcp (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wiznet_w5500_tcp +hex
  c flags: Optim=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F100xB
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: stm32f1xx_it.c main.c stm32f1xx_hal_msp.c network.c hardware.c engine.c utils.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rtc.c stm32f1xx_hal_uart.c
  group Ethernet
    ../Ethernet/: dhcp.c dhcp.h dns.c dns.h socket.c socket.h wizchip_conf.c wizchip_conf.h
    ../Ethernet/W5500/: w5500.c w5500.h
  group Json
    ../Json/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h
  group Linker
    ../: startup_stm32f100xb.s
